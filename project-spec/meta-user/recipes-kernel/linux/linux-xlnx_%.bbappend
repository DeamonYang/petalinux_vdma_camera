SRC_URI += "file://user_2020-11-29-17-51-00.cfg \
            file://user_2020-11-30-21-17-00.cfg \
            file://user_2021-02-03-20-00-00.cfg \
            "

FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

